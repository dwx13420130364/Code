# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: RT_USING_DLIBC; STM32U575xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\libraries\STM32U5xx_HAL\CMSIS\Include; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\posix\io\stdio; ..\..\..\components\drivers\include; ..\..\..\examples\utest\testcases\kernel; .; ..\..\..\libcpu\arm\cortex-m33; applications; ..\libraries\HAL_Drivers\config; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\io\poll; board\CubeMX_Config\Inc; ..\libraries\STM32U5xx_HAL\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\include; ..\libraries\STM32U5xx_HAL\STM32U5xx_HAL_Driver\Inc; ..\libraries\HAL_Drivers; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: stdlib.c time.c
    ../../../components/libc/compilers/dlib/: syscall_read.c syscall_write.c syscall_close.c syscall_lseek.c syscall_remove.c environ.c syscall_open.c syscall_mem.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m33/: syscall_iar.S trustzone.c context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c ringblk_buf.c workqueue.c waitqueue.c ringbuffer.c dataqueue.c pipe.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/iar/: startup_stm32u575xx.s
    board/CubeMX_Config/Src/: stm32u5xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: kservice.c components.c device.c mem.c scheduler.c clock.c idle.c thread.c ipc.c mempool.c object.c timer.c irq.c
  group Libraries
    ../libraries/STM32U5xx_HAL/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_uart.c stm32u5xx_hal.c stm32u5xx_hal_crc.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_usart.c stm32u5xx_hal_pwr.c stm32u5xx_hal_rcc.c stm32u5xx_hal_gpio.c stm32u5xx_hal_rng.c stm32u5xx_hal_cortex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/: system_stm32u5xx.c
