# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; STM32F746xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\libraries\STM32F7xx_HAL\CMSIS\Include; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\ipc; ..\..\..\libcpu\arm\cortex-m7; board\ports; ..\..\..\components\drivers\include; ..\..\..\components\libc\posix\io\stdio; ..\..\..\examples\utest\testcases\kernel; .; applications; ..\libraries\HAL_Drivers\config; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common; ..\libraries\STM32F7xx_HAL\STM32F7xx_HAL_Driver\Inc; board\CubeMX_Config\Inc; ..\libraries\STM32F7xx_HAL\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\include; ..\libraries\HAL_Drivers; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: stdlib.c time.c
    ../../../components/libc/compilers/dlib/: syscall_open.c syscall_read.c syscall_write.c syscall_remove.c syscall_close.c environ.c syscall_lseek.c syscall_mem.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../../libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/ipc/: completion.c ringblk_buf.c pipe.c waitqueue.c dataqueue.c ringbuffer.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f7xx_hal_msp.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c drv_hwtimer.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: thread.c kservice.c idle.c timer.c clock.c mempool.c ipc.c object.c device.c scheduler.c components.c irq.c mem.c
  group Libraries
    ../libraries/STM32F7xx_HAL/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sram.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_usart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cec.c stm32f7xx_hal_cryp.c stm32f7xx_hal_gpio.c stm32f7xx_hal_exti.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_lptim.c stm32f7xx_hal_crc_ex.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
