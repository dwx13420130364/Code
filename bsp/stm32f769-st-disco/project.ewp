# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; STM32F767xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; ..\libraries\STM32F7xx_HAL\CMSIS\Include; ..\..\..\components\net\lwip-2.0.3\src\include\netif; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common; board\CubeMX_Config\Inc; ..\libraries\STM32F7xx_HAL\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\components\libc\posix\ipc; ..\..\..\components\net\lwip-2.0.3\src\arch\include; ..\..\..\components\libc\posix\io\stdio; ..\..\..\components\net\lwip-2.0.3\src\include\ipv4; ..\..\..\examples\utest\testcases\kernel; .; ..\libraries\HAL_Drivers\config; board; ..\libraries\HAL_Drivers; ..\..\..\components\net\lwip-2.0.3\src\include; ..\..\..\components\net\lwip-2.0.3\src; applications; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m7; ..\..\..\components\net\lwip-2.0.3\src\include\posix; ..\libraries\STM32F7xx_HAL\STM32F7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: stdlib.c time.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_mem.c syscall_lseek.c syscall_close.c syscalls.c syscall_read.c syscall_write.c syscall_remove.c syscall_open.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: waitqueue.c workqueue.c ringbuffer.c pipe.c dataqueue.c ringblk_buf.c completion.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f767xx.s
    board/CubeMX_Config/Src/: stm32f7xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: mempool.c idle.c mem.c components.c kservice.c clock.c thread.c ipc.c object.c timer.c device.c scheduler.c irq.c
  group Libraries
    ../libraries/STM32F7xx_HAL/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_exti.c stm32f7xx_hal_rng.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cec.c stm32f7xx_hal_dma.c stm32f7xx_hal_uart.c stm32f7xx_hal_cryp.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group lwIP
    ../../../components/net/lwip-2.0.3/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    ../../../components/net/lwip-2.0.3/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    ../../../components/net/lwip-2.0.3/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    ../../../components/net/lwip-2.0.3/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../components/net/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../components/net/lwip-2.0.3/src/arch/: sys_arch.c
