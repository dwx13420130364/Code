# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; STM32F446xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\libraries\STM32F4xx_HAL\CMSIS\Include; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\..\..\components\libc\posix\io\stdio; ..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; ..\..\..\components\drivers\include; ..\..\..\components\libc\posix\ipc; ..\..\..\examples\utest\testcases\kernel; .; applications; ..\libraries\HAL_Drivers\config; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\io\poll; board\CubeMX_Config\Inc; ..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\include; ..\libraries\HAL_Drivers; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: stdlib.c time.c
    ../../../components/libc/compilers/dlib/: syscall_mem.c environ.c syscall_lseek.c syscall_remove.c syscall_read.c syscall_open.c syscall_close.c syscalls.c syscall_write.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: pipe.c ringbuffer.c completion.c workqueue.c waitqueue.c dataqueue.c ringblk_buf.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f446xx.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: mem.c timer.c object.c device.c ipc.c irq.c idle.c components.c mempool.c scheduler.c clock.c kservice.c thread.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
