# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L433RC ST STM32L433RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; STM32L431xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common; board\CubeMX_Config\Inc; ..\..\..\components\libc\posix\ipc; board\ports\lcd; ..\libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include; ..\libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc; ..\..\..\examples\utest\testcases\kernel; .; ..\libraries\STM32L4xx_HAL\CMSIS\Include; ..\libraries\HAL_Drivers\config; board; ..\..\..\components\drivers\spi; ..\libraries\HAL_Drivers; applications; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\..\..\components\libc\posix\io\stdio
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: time.c stdlib.c
    ../../../components/libc/compilers/dlib/: syscall_open.c syscall_lseek.c syscalls.c environ.c syscall_remove.c syscall_read.c syscall_write.c syscall_close.c syscall_mem.c
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: ringblk_buf.c pipe.c dataqueue.c ringbuffer.c completion.c workqueue.c waitqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l431xx.s
    board/ports/lcd/: drv_lcd.c
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c drv_spi.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: timer.c device.c object.c ipc.c clock.c scheduler.c thread.c irq.c mempool.c kservice.c components.c idle.c mem.c
  group Libraries
    ../libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_cryp.c stm32l4xx_hal_spi.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_rtc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_qspi.c stm32l4xx_hal_exti.c stm32l4xx_hal_rng.c stm32l4xx_hal_crc.c stm32l4xx_hal_uart_ex.c
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
