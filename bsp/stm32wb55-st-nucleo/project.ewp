# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VE ST STM32L475VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; STM32WB55xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\posix\ipc; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; board\ports; ..\..\..\components\drivers\include; ..\..\..\components\libc\posix\io\stdio; ..\..\..\examples\utest\testcases\kernel; .; applications; ..\libraries\HAL_Drivers\config; ..\..\..\components\libc\compilers\common\extension; ..\libraries\STM32WBxx_HAL\CMSIS\Include; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\io\poll; board\CubeMX_Config\Inc; ..\libraries\STM32WBxx_HAL\CMSIS\Device\ST\STM32WBxx\Include; ..\..\..\include; ..\libraries\STM32WBxx_HAL\STM32WBxx_HAL_Driver\Inc; ..\libraries\HAL_Drivers; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: time.c stdlib.c
    ../../../components/libc/compilers/dlib/: syscall_open.c syscall_write.c environ.c syscall_remove.c syscall_mem.c syscalls.c syscall_read.c syscall_lseek.c syscall_close.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/ipc/: ringblk_buf.c dataqueue.c completion.c ringbuffer.c pipe.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/STM32WBxx_HAL/CMSIS/Device/ST/STM32WBxx/Source/Templates/iar/: startup_stm32wb55xx_cm4.s
    board/CubeMX_Config/Src/: stm32wbxx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: components.c irq.c idle.c mempool.c timer.c object.c kservice.c scheduler.c ipc.c mem.c device.c thread.c clock.c
  group Libraries
    ../libraries/STM32WBxx_HAL/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_hsem.c stm32wbxx_hal_pwr.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_usart.c stm32wbxx_hal.c stm32wbxx_hal_gpio.c stm32wbxx_hal_cortex.c stm32wbxx_hal_exti.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_cryp_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_usart_ex.c stm32wbxx_hal_rng.c stm32wbxx_hal_crc.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cryp.c stm32wbxx_hal_comp.c
    ../libraries/STM32WBxx_HAL/CMSIS/Device/ST/STM32WBxx/Source/Templates/: system_stm32wbxx.c
