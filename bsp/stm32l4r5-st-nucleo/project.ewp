# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R5ZI ST STM32L4R5ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; STM32L4R5xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\posix\ipc; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include; ..\libraries\STM32L4xx_HAL\CMSIS\Include; ..\..\..\components\drivers\include; ..\..\..\components\libc\posix\io\stdio; ..\libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc; ..\..\..\examples\utest\testcases\kernel; .; applications; ..\libraries\HAL_Drivers\config; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\io\poll; board\CubeMX_Config\Inc; ..\..\..\include; ..\libraries\HAL_Drivers; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: time.c stdlib.c
    ../../../components/libc/compilers/dlib/: syscall_open.c syscall_close.c syscall_remove.c syscall_read.c environ.c syscall_mem.c syscall_lseek.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/ipc/: waitqueue.c completion.c workqueue.c dataqueue.c ringblk_buf.c pipe.c ringbuffer.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l4r5xx.s
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: components.c object.c kservice.c memheap.c timer.c mem.c clock.c thread.c idle.c scheduler.c ipc.c device.c irq.c
  group Libraries
    ../libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_cryp.c stm32l4xx_hal_uart.c stm32l4xx_hal_usart.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_crc.c stm32l4xx_hal.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_cryp_ex.c
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
