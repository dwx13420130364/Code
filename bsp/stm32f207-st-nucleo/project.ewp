# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F207xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\libcpu\arm\cortex-m3; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; board\CubeMX_Config\Core\Inc; ..\libraries\STM32F2xx_HAL\CMSIS\Include; ..\..\..\components\drivers\include; ..\libraries\STM32F2xx_HAL\CMSIS\Device\ST\STM32F2xx\Include; .; applications; ..\libraries\HAL_Drivers\config; board; ..\..\..\components\libc\compilers\common; ..\libraries\STM32F2xx_HAL\STM32F2xx_HAL_Driver\Inc; ..\..\..\include; ..\libraries\HAL_Drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: dataqueue.c workqueue.c pipe.c waitqueue.c ringblk_buf.c completion.c ringbuffer.c
  group Drivers
    board/CubeMX_Config/Core/Src/: stm32f2xx_hal_msp.c
    ../libraries/STM32F2xx_HAL/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f207xx.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: scheduler.c timer.c idle.c clock.c thread.c ipc.c object.c kservice.c mem.c components.c device.c mempool.c irq.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32F2xx_HAL/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_usart.c stm32f2xx_hal_cortex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc.c stm32f2xx_hal_crc.c stm32f2xx_hal_sram.c stm32f2xx_hal_pwr.c stm32f2xx_hal_dma.c stm32f2xx_hal.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_uart.c
    ../libraries/STM32F2xx_HAL/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
