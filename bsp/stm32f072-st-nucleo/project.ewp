# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; STM32F072xB; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\libcpu\arm\cortex-m0; ..\..\..\components\libc\posix\ipc; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\libraries\STM32F0xx_HAL\STM32F0xx_HAL_Driver\Inc; ..\..\..\components\libc\posix\io\stdio; ..\..\..\components\drivers\include; ..\..\..\examples\utest\testcases\kernel; .; applications; ..\libraries\STM32F0xx_HAL\CMSIS\Include; ..\libraries\HAL_Drivers\config; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\io\poll; board\CubeMX_Config\Inc; ..\libraries\STM32F0xx_HAL\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\include; ..\libraries\HAL_Drivers; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: stdlib.c time.c
    ../../../components/libc/compilers/dlib/: syscall_open.c syscall_lseek.c syscalls.c syscall_close.c syscall_remove.c syscall_write.c syscall_mem.c environ.c syscall_read.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: ringblk_buf.c waitqueue.c completion.c ringbuffer.c dataqueue.c workqueue.c pipe.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f072xb.s
    board/: board.c
    board/CubeMX_Config/Src/: stm32f0xx_hal_msp.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: irq.c ipc.c mempool.c kservice.c object.c device.c mem.c idle.c scheduler.c clock.c components.c timer.c thread.c
  group Libraries
    ../libraries/STM32F0xx_HAL/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_pwr.c stm32f0xx_ll_utils.c stm32f0xx_hal_uart.c stm32f0xx_hal_rcc.c stm32f0xx_hal_crc_ex.c stm32f0xx_ll_pwr.c stm32f0xx_hal_crc.c stm32f0xx_hal.c stm32f0xx_hal_rcc_ex.c stm32f0xx_ll_crc.c stm32f0xx_ll_usart.c stm32f0xx_ll_exti.c stm32f0xx_hal_dma.c stm32f0xx_ll_rcc.c stm32f0xx_hal_gpio.c stm32f0xx_ll_dma.c
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
