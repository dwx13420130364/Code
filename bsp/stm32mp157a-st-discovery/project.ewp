# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157A_M4 ST STM32MP157A_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; CORE_CM4; NO_ATOMIC_64_SUPPORT; METAL_INTERNAL; METAL_MAX_DEVICE_REGIONS=2; VIRTIO_SLAVE_ONLY; STM32MP157Axx; __LOG_TRACE_IO_; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; ..\libraries\STM32MPxx_HAL\CMSIS\Core\Include; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\common\extension; board\ports\audio; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\ipc; board\CubeMX_Config\CM4\Inc; ..\..\..\components\libc\posix\io\stdio; ..\..\..\examples\utest\testcases\kernel; .; ..\libraries\HAL_Drivers\config; board; ..\libraries\HAL_Drivers; board\ports; applications; ..\libraries\STM32MPxx_HAL\CMSIS\Include; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; ..\libraries\STM32MPxx_HAL\CMSIS\Device\ST\STM32MP1xx\Include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\libraries\STM32MPxx_HAL\STM32MP1xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.bin
  ILINK.IlinkOutputFile: RT-Thread-STM32MP1_CM4.elf
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: time.c stdlib.c
    ../../../components/libc/compilers/dlib/: syscall_read.c syscall_write.c syscall_close.c syscall_remove.c syscalls.c environ.c syscall_lseek.c syscall_mem.c syscall_open.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/ipc/: ringblk_buf.c waitqueue.c completion.c workqueue.c ringbuffer.c pipe.c dataqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/CubeMX_Config/Common/System/: system_stm32mp1xx.c
    board/CubeMX_Config/CM4/Src/: stm32mp1xx_hal_msp.c
    board/: board.c
    ../libraries/STM32MPxx_HAL/CMSIS/Device/ST/STM32MP1xx/Source/Templates/iar/: startup_stm32mp15xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: scheduler.c idle.c memheap.c kservice.c device.c irq.c clock.c timer.c ipc.c components.c thread.c mempool.c object.c
  group Libraries
    ../libraries/STM32MPxx_HAL/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_spi.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_uart_ex.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_tim_ex.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_dma.c stm32mp1xx_hal.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_mdma.c
