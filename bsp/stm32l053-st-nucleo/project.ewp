# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; STM32L053xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\libcpu\arm\cortex-m0; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\posix\io\stdio; ..\..\..\components\drivers\include; ..\..\..\examples\utest\testcases\kernel; .; applications; ..\libraries\HAL_Drivers\config; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\compilers\common\extension; ..\libraries\STM32L0xx_HAL\CMSIS\Include; ..\..\..\components\libc\compilers\common; ..\libraries\STM32L0xx_HAL\STM32L0xx_HAL_Driver\Inc; board\CubeMX_Config\Inc; ..\libraries\STM32L0xx_HAL\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\include; ..\libraries\HAL_Drivers; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: time.c stdlib.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_write.c syscall_close.c syscall_lseek.c syscalls.c syscall_remove.c syscall_open.c syscall_mem.c syscall_read.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: waitqueue.c ringblk_buf.c ringbuffer.c workqueue.c dataqueue.c pipe.c completion.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/STM32L0xx_HAL/CMSIS/Device/ST/STM32L0xx/Source/Templates/iar/: startup_stm32l053xx.s
    board/CubeMX_Config/Src/: stm32l0xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: irq.c idle.c object.c mem.c ipc.c timer.c device.c clock.c thread.c scheduler.c components.c mempool.c kservice.c
  group Libraries
    ../libraries/STM32L0xx_HAL/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_pwr.c stm32l0xx_hal_crc.c stm32l0xx_hal.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_rng.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_dma.c stm32l0xx_hal_usart.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_cryp_ex.c
    ../libraries/STM32L0xx_HAL/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
