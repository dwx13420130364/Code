# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; STM32F407xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\libraries\STM32F4xx_HAL\CMSIS\Include; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\..\..\components\libc\posix\io\stdio; ..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; ..\..\..\components\drivers\include; ..\..\..\components\libc\posix\ipc; ..\..\..\examples\utest\testcases\kernel; .; applications; ..\libraries\HAL_Drivers\config; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\io\poll; board\CubeMX_Config\Inc; ..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\include; ..\libraries\HAL_Drivers; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: stdlib.c time.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_lseek.c syscall_mem.c syscall_read.c syscalls.c syscall_write.c syscall_close.c syscall_remove.c syscall_open.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: dataqueue.c waitqueue.c pipe.c completion.c ringblk_buf.c ringbuffer.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: components.c thread.c kservice.c clock.c timer.c object.c scheduler.c device.c mempool.c ipc.c mem.c irq.c idle.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
